# IAR project KNXStack.ewp, settings and files
configuration Debug (68HC12, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlhcs12nfn.h
  General.GHeapSize: 512
  General.GStackSize: 64
  General.OGChipSelectMenu: mc9s12dp256b MC9S12DP256B
  ICC6812.CCIncludePath2: C:\projekte\csProjects\trunk\autosar; C:\projekte\csProjects\trunk; C:\projekte\csProjects\trunk\drivers\include; C:\projekte\csProjects\trunk\drivers\include\cpu12; C:\projekte\csProjects\trunk\common\include
  ICC6812.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  A6812.ADefines: __NORMAL_MODEL__
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmc9s12dp256b.xcl
configuration Release (68HC12)
  as the first configuration, except:
  ICC6812.CCDefines: NDEBUG
  ICC6812.CCIncludePath2: C:\projekte\csProjects\trunk\autosar; C:\projekte\csProjects\trunk; C:\projekte\csProjects\trunk\drivers\include; C:\projekte\csProjects\trunk\drivers\include\cpu12
  group (top)
    ../../../stack/: Address.c AIL.c ALG.c ALM.c Appl.c BABCU2.c ios.c knx_disp.c knx_tlc.c knx_tlg.c KNXConv.c KNXNwps.c lsm.c Memory.c Messaging.c Network.c rsm.c StateMachineKNX.c sys_objs.c timer.c tpuart.c
    ../../../: ooc.c
    ../../../../../csProjects/trunk/common/src/: Utl.c
