# IAR project cpptest.ewp, settings and files
configuration Debug (68HC12, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlhcs12nfn.h
  General.GHeapSize: 512
  General.GStackSize: 64
  General.OGChipSelectMenu: hcs12 Generic HCS12
  ICC6812.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  A6812.ADefines: __NORMAL_MODEL__
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkhcs12.xcl
configuration Release (68HC12)
  as the first configuration, except:
  ICC6812.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.cpp
