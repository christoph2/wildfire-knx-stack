<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>68HC12</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>9</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>NewCInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>SIMHCS12</state>
        </option>
        <option>
          <name>CUseDdfFile</name>
          <state>0</state>
        </option>
        <option>
          <name>CDDFFile</name>
          <state>$TOOLKIT_DIR$\config\iomc9s12dp256b.ddf</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>BDMHCS12</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CBdmMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>ChipMode</name>
          <version>0</version>
          <state>3</state>
        </option>
        <option>
          <name>SuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>SuppressFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>SuppressEEPROMDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>VerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>SmartErase</name>
          <state>0</state>
        </option>
        <option>
          <name>XtalFrequency</name>
          <state>16000</state>
        </option>
        <option>
          <name>CommunicationType</name>
          <version>0</version>
          <state>4</state>
        </option>
        <option>
          <name>CommunicationPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>BaudRate</name>
          <version>0</version>
          <state>6</state>
        </option>
        <option>
          <name>CommunicationSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>ClearCLKSW</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMHCS12</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\codecoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\orti.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\stack.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>68HC12</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>9</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>NewCInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>SIMHCS12</state>
        </option>
        <option>
          <name>CUseDdfFile</name>
          <state>0</state>
        </option>
        <option>
          <name>CDDFFile</name>
          <state></state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>BDMHCS12</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CBdmMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>ChipMode</name>
          <version>0</version>
          <state>3</state>
        </option>
        <option>
          <name>SuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>SuppressFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>SuppressEEPROMDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>VerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>SmartErase</name>
          <state>0</state>
        </option>
        <option>
          <name>XtalFrequency</name>
          <state>16000</state>
        </option>
        <option>
          <name>CommunicationType</name>
          <version>0</version>
          <state>4</state>
        </option>
        <option>
          <name>CommunicationPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>BaudRate</name>
          <version>0</version>
          <state>6</state>
        </option>
        <option>
          <name>CommunicationSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>ClearCLKSW</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMHCS12</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\codecoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\orti.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\stack.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


